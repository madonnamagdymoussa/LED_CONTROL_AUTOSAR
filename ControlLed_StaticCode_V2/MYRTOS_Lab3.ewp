# IAR project MYRTOS_Lab3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\IAR_WorkSpace\MYRTOS_Lab3\MYRTOS_Lab3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Application1_SWC_ButtonStateReading.c Application2_SWC_LedSwitching.c CortexM.c CortexM.h CortexM_Reg.h DIO.c DIO.h Dio_Config.h Dio_LCfg.c Dio_LCfg.h Dio_Types.h GPTM.C GPTM.h GPTM_config.c GPTM_config.h GPTM_reg.h IOA_SWC_1.c lstd.h main.c NVIC.c NVIC.h NVIC_config.h NVIC_reg.h Port.c Port.h Port_Cfg.h Port_Config.h PORT_DIO_Config.c PORT_DIO_Config.h Port_LCfg.c Port_LCfg.h Port_Reg.h Port_Types.h Rte.c Rte.h Rte_Application1_SWC_ButtonStateReading.h Rte_Application2_SWC_LedSwitching.h Rte_IOA_SWC_1.h Rte_Type.h Scheduler.c Scheduler.h startup_ewarm.c Std_Types.h SystemControl.c SystemControl.h SystemControl_Config.c SystemControl_config.h SystemControl_reg.h SystickTimer.c SystickTimer.h SystickTimer_reg.h Task.c Task.h
